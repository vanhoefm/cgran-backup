<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>gr_keep_one_in_n</key>
<param><key>id</key><value>gr_keep_one_in_n_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>n</key><value>synoptic_ratio</value></param>
<param><key>vlen</key><value>synoptic_length</value></param>
</block>
<block>
<key>gr_stream_to_vector</key>
<param><key>id</key><value>gr_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>synoptic_length</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>import sidsuite</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import notchfilt</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_3</value></param>
<param><key>note</key><value>Options, imports, etc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>f4</value></param>
<param><key>value</key><value>18.5e3</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>f3</value></param>
<param><key>value</key><value>22.5e3</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>f2</value></param>
<param><key>value</key><value>19.50e3</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>f1</value></param>
<param><key>value</key><value>24.0e3</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>f5</value></param>
<param><key>value</key><value>19.5e3</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>f6</value></param>
<param><key>value</key><value>14.5e3</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>hz</value></param>
<param><key>value</key><value>60</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>96000</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>integ</value></param>
<param><key>value</key><value>5.0</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>igain</value></param>
<param><key>value</key><value>1</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>GUI controls</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>audio_shift</value></param>
<param><key>value</key><value>23.0e3</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>audio_width</value></param>
<param><key>value</key><value>6.0e3</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>integration</value></param>
<param><key>label</key><value>Post Detector Integration</value></param>
<param><key>value</key><value>integ</value></param>
<param><key>min</key><value>1</value></param>
<param><key>max</key><value>101</value></param>
<param><key>num_steps</key><value>200</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>notebook</key><value>MainNotebook, 0</value></param>
</block>
<block>
<key>gr_complex_to_real</key>
<param><key>id</key><value>gr_complex_to_real_1</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>gr_file_sink_4</value></param>
<param><key>file</key><value>synoptic_output</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>synoptic_length</value></param>
<param><key>unbuffered</key><value>False</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>gr_file_sink_1_0_0</value></param>
<param><key>file</key><value>sid_ch2.dat</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>converter_taps</value></param>
<param><key>value</key><value>gr.firdes.low_pass(1.0,samp_rate,width,width/5,gr.firdes.WIN_HAMMING)</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>gr_file_sink_1_0_0_0_0</value></param>
<param><key>file</key><value>sid_ch4.dat</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>Command line params</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2</value></param>
<param><key>note</key><value>Computed Variables</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>synoptic_length</value></param>
<param><key>value</key><value>int(100e3)</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cfn</value></param>
<param><key>value</key><value>/dev/null</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>synoptic_ratio</value></param>
<param><key>value</key><value>10</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_taps</value></param>
<param><key>value</key><value>gr.firdes.low_pass(1750.0,samp_rate,300,45,gr.firdes.WIN_HAMMING)</value></param>
</block>
<block>
<key>gr_freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>gr_freq_xlating_fir_filter_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>2</value></param>
<param><key>taps</key><value>converter_taps</value></param>
<param><key>center_freq</key><value>-1*(start_freq)</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ohwname</value></param>
<param><key>value</key><value>hw:1,0</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>hwname</value></param>
<param><key>value</key><value>hw:0,0</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>device_name</key><value>hwname</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>start_freq</value></param>
<param><key>label</key><value>Audio Start Freq</value></param>
<param><key>value</key><value>audio_shift</value></param>
<param><key>min</key><value>100.0</value></param>
<param><key>max</key><value>45.0e3</value></param>
<param><key>num_steps</key><value>800</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>notebook</key><value>MainNotebook, 0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>width</value></param>
<param><key>label</key><value>Audio Capture Width</value></param>
<param><key>value</key><value>audio_width</value></param>
<param><key>min</key><value>300</value></param>
<param><key>max</key><value>14.3e3</value></param>
<param><key>num_steps</key><value>140</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>notebook</key><value>MainNotebook, 0</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>chan1_freq</value></param>
<param><key>label</key><value>Channel 1 Frequency</value></param>
<param><key>value</key><value>f1</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>notebook</key><value>MainNotebook, 0</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>chan2_freq</value></param>
<param><key>label</key><value>Channel 2 Frequency</value></param>
<param><key>value</key><value>f2</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>notebook</key><value>MainNotebook, 0</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>chan3_freq</value></param>
<param><key>label</key><value>Channel 3 Frequency</value></param>
<param><key>value</key><value>f3</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>notebook</key><value>MainNotebook, 0</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>chan4_freq</value></param>
<param><key>label</key><value>Channel 4 Frequency</value></param>
<param><key>value</key><value>f4</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>notebook</key><value>MainNotebook, 0</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>chan5_freq</value></param>
<param><key>label</key><value>Channel 5 Frequency</value></param>
<param><key>value</key><value>f5</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>notebook</key><value>MainNotebook, 0</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>chan6_freq</value></param>
<param><key>label</key><value>Channel 6 Frequency</value></param>
<param><key>value</key><value>f6</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>notebook</key><value>MainNotebook, 0</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>MainNotebook</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
<param><key>labels</key><value>['Main', 'Spectral']</value></param>
</block>
<block>
<key>gr_complex_to_real</key>
<param><key>id</key><value>gr_complex_to_real_0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>int(samp_rate/2)</value></param>
<param><key>device_name</key><value>ohwname</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>0.125</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_agc2_xx</key>
<param><key>id</key><value>gr_agc2_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>attack_rate</key><value>1e-4</value></param>
<param><key>decay_rate</key><value>3e-5</value></param>
<param><key>reference</key><value>0.75</value></param>
<param><key>gain</key><value>0.75</value></param>
<param><key>max_gain</key><value>0.75</value></param>
</block>
<block>
<key>gr_hilbert_fc</key>
<param><key>id</key><value>gr_hilbert_fc_0</value></param>
<param><key>num_taps</key><value>32</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>gr_file_sink_1_0</value></param>
<param><key>file</key><value>sid_ch1.dat</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>gr_complex_to_mag</key>
<param><key>id</key><value>gr_complex_to_mag_0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_complex_to_mag</key>
<param><key>id</key><value>gr_complex_to_mag_0_0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_single_pole_iir_filter_xx</key>
<param><key>id</key><value>gr_single_pole_iir_filter_xx_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>alpha</key><value>1.0/(integration*200)</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>gr_file_sink_1_0_0_0</value></param>
<param><key>file</key><value>sid_ch3.dat</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>gr_complex_to_mag</key>
<param><key>id</key><value>gr_complex_to_mag_0_0_0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_single_pole_iir_filter_xx</key>
<param><key>id</key><value>gr_single_pole_iir_filter_xx_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>alpha</key><value>1.0/(integration*200)</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>gr_file_sink_1_0_0_0_0_0</value></param>
<param><key>file</key><value>sid_ch5.dat</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>gr_file_sink_1_0_0_0_0_0_0</value></param>
<param><key>file</key><value>sid_ch6.dat</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>gr_complex_to_mag</key>
<param><key>id</key><value>gr_complex_to_mag_0_0_0_0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_single_pole_iir_filter_xx</key>
<param><key>id</key><value>gr_single_pole_iir_filter_xx_0_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>alpha</key><value>1.0/(integration*200)</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_complex_to_mag</key>
<param><key>id</key><value>gr_complex_to_mag_0_0_0_0_0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_complex_to_mag</key>
<param><key>id</key><value>gr_complex_to_mag_0_0_0_0_0_0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_single_pole_iir_filter_xx</key>
<param><key>id</key><value>gr_single_pole_iir_filter_xx_0_0_0_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>alpha</key><value>1.0/(integration*200)</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>igain</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_fft_filter_xxx</key>
<param><key>id</key><value>gr_fft_filter_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>notchfilt.notch_taps(samp_rate,hz,(samp_rate/2)/hz)</value></param>
<param><key>nthreads</key><value>1</value></param>
</block>
<block>
<key>gr_complex_to_real</key>
<param><key>id</key><value>gr_complex_to_real_2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>100</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_single_pole_iir_filter_xx</key>
<param><key>id</key><value>gr_single_pole_iir_filter_xx_0_0_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>alpha</key><value>1.0/(integration*200)</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_goertzel_fc</key>
<param><key>id</key><value>gr_goertzel_fc_1</value></param>
<param><key>rate</key><value>samp_rate</value></param>
<param><key>len</key><value>int(samp_rate/cbw)</value></param>
<param><key>freq</key><value>chan2_freq</value></param>
</block>
<block>
<key>gr_goertzel_fc</key>
<param><key>id</key><value>gr_goertzel_fc_1_0</value></param>
<param><key>rate</key><value>samp_rate</value></param>
<param><key>len</key><value>int(samp_rate/cbw)</value></param>
<param><key>freq</key><value>chan3_freq</value></param>
</block>
<block>
<key>gr_goertzel_fc</key>
<param><key>id</key><value>gr_goertzel_fc_1_0_0</value></param>
<param><key>rate</key><value>samp_rate</value></param>
<param><key>len</key><value>int(samp_rate/cbw)</value></param>
<param><key>freq</key><value>chan4_freq</value></param>
</block>
<block>
<key>gr_goertzel_fc</key>
<param><key>id</key><value>gr_goertzel_fc_1_0_0_0</value></param>
<param><key>rate</key><value>samp_rate</value></param>
<param><key>len</key><value>int(samp_rate/cbw)</value></param>
<param><key>freq</key><value>chan5_freq</value></param>
</block>
<block>
<key>gr_goertzel_fc</key>
<param><key>id</key><value>gr_goertzel_fc_1_0_0_0_0</value></param>
<param><key>rate</key><value>samp_rate</value></param>
<param><key>len</key><value>int(samp_rate/cbw)</value></param>
<param><key>freq</key><value>chan6_freq</value></param>
</block>
<block>
<key>gr_keep_one_in_n</key>
<param><key>id</key><value>gr_keep_one_in_n_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>n</key><value>cbw/10</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_keep_one_in_n</key>
<param><key>id</key><value>gr_keep_one_in_n_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>n</key><value>cbw/10</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_keep_one_in_n</key>
<param><key>id</key><value>gr_keep_one_in_n_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>n</key><value>cbw/10</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_keep_one_in_n</key>
<param><key>id</key><value>gr_keep_one_in_n_0_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>n</key><value>cbw/10</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_keep_one_in_n</key>
<param><key>id</key><value>gr_keep_one_in_n_0_0_0_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>n</key><value>cbw/10</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_goertzel_fc</key>
<param><key>id</key><value>gr_goertzel_fc_0</value></param>
<param><key>rate</key><value>samp_rate</value></param>
<param><key>len</key><value>int(samp_rate/cbw)</value></param>
<param><key>freq</key><value>chan1_freq</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cbw</value></param>
<param><key>value</key><value>300</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Instantaneous Spectrum</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>50</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>2048</value></param>
<param><key>fft_rate</key><value>5</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.03</value></param>
<param><key>win</key><value>None</value></param>
<param><key>win_size</key><value>800,400</value></param>
<param><key>notebook</key><value>MainNotebook, 1</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Spectrogram</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>dynamic_range</key><value>50</value></param>
<param><key>ref_level</key><value>45</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>2048</value></param>
<param><key>fft_rate</key><value>3</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.03</value></param>
<param><key>win</key><value>None</value></param>
<param><key>win_size</key><value>800,400</value></param>
<param><key>notebook</key><value>MainNotebook, 1</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>gr_keep_one_in_n</key>
<param><key>id</key><value>gr_keep_one_in_n_0_0_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>n</key><value>cbw/10</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_keep_one_in_n</key>
<param><key>id</key><value>gr_keep_one_in_n_0_0_0_0_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>n</key><value>int(cbw/strip_out_rate)</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_keep_one_in_n</key>
<param><key>id</key><value>gr_keep_one_in_n_0_0_0_0_1_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>n</key><value>int(cbw/strip_out_rate)</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_keep_one_in_n</key>
<param><key>id</key><value>gr_keep_one_in_n_0_0_0_0_1_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>n</key><value>int(cbw/strip_out_rate)</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_keep_one_in_n</key>
<param><key>id</key><value>gr_keep_one_in_n_0_0_0_0_1_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>n</key><value>int(cbw/strip_out_rate)</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_keep_one_in_n</key>
<param><key>id</key><value>gr_keep_one_in_n_0_0_0_0_1_0_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>n</key><value>int(cbw/strip_out_rate)</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_keep_one_in_n</key>
<param><key>id</key><value>gr_keep_one_in_n_0_0_0_0_1_0_0_0_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>n</key><value>int(cbw/strip_out_rate)</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>MyScopeSink</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Rx Channels RMS Power</value></param>
<param><key>samp_rate</key><value>strip_out_rate</value></param>
<param><key>v_scale</key><value>10</value></param>
<param><key>v_offset</key><value>250</value></param>
<param><key>t_scale</key><value>450.0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>6</value></param>
<param><key>win_size</key><value>(700,500)</value></param>
<param><key>notebook</key><value>MainNotebook, 0</value></param>
<param><key>trig_mode</key><value>gr.gr_TRIG_MODE_STRIPCHART</value></param>
<param><key>y_axis_label</key><value>Detected Power</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>strip_out_rate</value></param>
<param><key>value</key><value>1.0/5.0</value></param>
</block>
<block>
<key>gr_single_pole_iir_filter_xx</key>
<param><key>id</key><value>gr_single_pole_iir_filter_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>alpha</key><value>1.0/(integration*200)</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sidvars</value></param>
<param><key>value</key><value>sidsuite.variables(cfn,chan1_freq,chan2_freq,chan3_freq,chan4_freq,chan5_freq,chan6_freq,integration,0,0,igain,width,start_freq)</value></param>
</block>
<block>
<key>xmlrpc_server</key>
<param><key>id</key><value>xmlrpc_server_0</value></param>
<param><key>addr</key><value>localhost</value></param>
<param><key>port</key><value>8977</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>audioSIDnetRcvr</value></param>
<param><key>title</key><value>Sudden Ionospheric Disturbance Receiver</value></param>
<param><key>author</key><value>Marcus D. Leec (patchvonbraun), Science Radio Laboratories, Inc</value></param>
<param><key>description</key><value>Six channel SID receiver, use with audio I/O</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<connection><source_block_id>gr_stream_to_vector_0</source_block_id><sink_block_id>gr_keep_one_in_n_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_keep_one_in_n_1</source_block_id><sink_block_id>gr_file_sink_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_keep_one_in_n_0_0</source_block_id><sink_block_id>gr_file_sink_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_hilbert_fc_0</source_block_id><sink_block_id>gr_fft_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_fft_filter_xxx_0</source_block_id><sink_block_id>gr_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>gr_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_fft_filter_xxx_0</source_block_id><sink_block_id>gr_freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_keep_one_in_n_0_0_0_0_0</source_block_id><sink_block_id>gr_file_sink_1_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_keep_one_in_n_0_0_0_0_0_0</source_block_id><sink_block_id>gr_file_sink_1_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_keep_one_in_n_0_0_0_0_1</source_block_id><sink_block_id>MyScopeSink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_keep_one_in_n_0_0_0_0_1_0</source_block_id><sink_block_id>MyScopeSink</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_keep_one_in_n_0_0_0_0_1_0_0</source_block_id><sink_block_id>MyScopeSink</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>gr_keep_one_in_n_0_0_0_0_1_0_0_0</source_block_id><sink_block_id>MyScopeSink</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>gr_keep_one_in_n_0_0_0_0_1_0_0_0_0</source_block_id><sink_block_id>MyScopeSink</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>gr_keep_one_in_n_0_0_0_0_1_0_0_0_1</source_block_id><sink_block_id>MyScopeSink</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>gr_complex_to_real_1</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_real_1</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_fft_filter_xxx_0</source_block_id><sink_block_id>gr_complex_to_real_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>gr_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0</source_block_id><sink_block_id>gr_hilbert_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_real_0</source_block_id><sink_block_id>gr_agc2_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_agc2_xx_0</source_block_id><sink_block_id>gr_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_1</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_single_pole_iir_filter_xx_0</source_block_id><sink_block_id>gr_keep_one_in_n_0_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_keep_one_in_n_0</source_block_id><sink_block_id>gr_file_sink_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_single_pole_iir_filter_xx_0</source_block_id><sink_block_id>gr_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_goertzel_fc_0</source_block_id><sink_block_id>gr_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_mag_0</source_block_id><sink_block_id>gr_single_pole_iir_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_real_2</source_block_id><sink_block_id>gr_goertzel_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_real_2</source_block_id><sink_block_id>gr_goertzel_fc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_goertzel_fc_1</source_block_id><sink_block_id>gr_complex_to_mag_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_mag_0_0</source_block_id><sink_block_id>gr_single_pole_iir_filter_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_single_pole_iir_filter_xx_0_0</source_block_id><sink_block_id>gr_keep_one_in_n_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_single_pole_iir_filter_xx_0_0</source_block_id><sink_block_id>gr_keep_one_in_n_0_0_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_real_2</source_block_id><sink_block_id>gr_goertzel_fc_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_goertzel_fc_1_0</source_block_id><sink_block_id>gr_complex_to_mag_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_mag_0_0_0</source_block_id><sink_block_id>gr_single_pole_iir_filter_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_keep_one_in_n_0_0_0</source_block_id><sink_block_id>gr_file_sink_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_single_pole_iir_filter_xx_0_0_0</source_block_id><sink_block_id>gr_keep_one_in_n_0_0_0_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_real_2</source_block_id><sink_block_id>gr_goertzel_fc_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_goertzel_fc_1_0_0</source_block_id><sink_block_id>gr_complex_to_mag_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_mag_0_0_0_0</source_block_id><sink_block_id>gr_single_pole_iir_filter_xx_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_single_pole_iir_filter_xx_0_0_0</source_block_id><sink_block_id>gr_keep_one_in_n_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_single_pole_iir_filter_xx_0_0_0_0</source_block_id><sink_block_id>gr_keep_one_in_n_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_single_pole_iir_filter_xx_0_0_0_0</source_block_id><sink_block_id>gr_keep_one_in_n_0_0_0_0_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_real_2</source_block_id><sink_block_id>gr_goertzel_fc_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_real_2</source_block_id><sink_block_id>gr_goertzel_fc_1_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_goertzel_fc_1_0_0_0</source_block_id><sink_block_id>gr_complex_to_mag_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_goertzel_fc_1_0_0_0_0</source_block_id><sink_block_id>gr_complex_to_mag_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_mag_0_0_0_0_0</source_block_id><sink_block_id>gr_single_pole_iir_filter_xx_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_mag_0_0_0_0_0_0</source_block_id><sink_block_id>gr_single_pole_iir_filter_xx_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_single_pole_iir_filter_xx_0_0_0_0_0_0</source_block_id><sink_block_id>gr_keep_one_in_n_0_0_0_0_1_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_fft_filter_xxx_0</source_block_id><sink_block_id>gr_multiply_const_vxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_2</source_block_id><sink_block_id>gr_complex_to_real_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_single_pole_iir_filter_xx_0_0_0_0_0_0</source_block_id><sink_block_id>gr_keep_one_in_n_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_single_pole_iir_filter_xx_0_0_0_0_0</source_block_id><sink_block_id>gr_keep_one_in_n_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_single_pole_iir_filter_xx_0_0_0_0_0</source_block_id><sink_block_id>gr_keep_one_in_n_0_0_0_0_1_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_keep_one_in_n_0_0_0_0</source_block_id><sink_block_id>gr_file_sink_1_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
