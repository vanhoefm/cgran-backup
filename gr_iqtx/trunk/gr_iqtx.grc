<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>gr_iqtx</value></param>
<param><key>title</key><value>I/Q Baseband Transmitter+RX Monitor with Preemphasis</value></param>
<param><key>author</key><value>Marcus Leech, Science Radio Laboratories</value></param>
<param><key>description</key><value>A simple "baseband copier" for any I+Q input</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>gr_file_source</key>
<param><key>id</key><value>gr_file_source_0</value></param>
<param><key>file</key><value>/dev/stdin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_add_xx</key>
<param><key>id</key><value>gr_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>test_tones</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0</value></param>
<param><key>note</key><value>Test tones, 100Khz from band edge</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1</value></param>
<param><key>note</key><value>Complex Baseband in here</value></param>
</block>
<block>
<key>gr_sig_source_x</key>
<param><key>id</key><value>gr_sig_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>srate</value></param>
<param><key>waveform</key><value>gr.GR_COS_WAVE</value></param>
<param><key>freq</key><value>(srate/2)-offset</value></param>
<param><key>amp</key><value>tval</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>gr_sig_source_x</key>
<param><key>id</key><value>gr_sig_source_x_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>srate</value></param>
<param><key>waveform</key><value>gr.GR_COS_WAVE</value></param>
<param><key>freq</key><value>-(srate/2)+offset</value></param>
<param><key>amp</key><value>tval</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>preimport</value></param>
<param><key>import</key><value>import preemph</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>tweak</value></param>
<param><key>label</key><value>Fine TX frequency</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-2500</value></param>
<param><key>max</key><value>2500</value></param>
<param><key>num_steps</key><value>250</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>TX RF Gain</value></param>
<param><key>value</key><value>rfgain</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>50.0</value></param>
<param><key>num_steps</key><value>50</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0,3,1,1</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>pre_on</value></param>
<param><key>label</key><value>Preemphasis On</value></param>
<param><key>value</key><value>prex</value></param>
<param><key>true</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>grid_pos</key><value>0,1,1,1</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tlevel</value></param>
<param><key>label</key><value>test-tone level (dB)</value></param>
<param><key>value</key><value>-20</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>devid</value></param>
<param><key>label</key><value>device id</value></param>
<param><key>value</key><value>type=usrp1</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>txant</value></param>
<param><key>label</key><value>transmit antenna port</value></param>
<param><key>value</key><value>TX/RX</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pemph</value></param>
<param><key>label</key><value>Preemphasis filter on/off</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ton</value></param>
<param><key>label</key><value>test-tone on/off</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dbspec</value></param>
<param><key>label</key><value>daughterboard spec</value></param>
<param><key>value</key><value>A:0</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>CLIPLIM</value></param>
<param><key>value</key><value>0.9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>LOGCLIP</value></param>
<param><key>value</key><value>preemph.log_clipping(probeout,CLIPLIM,"clipping.log")</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tval</value></param>
<param><key>value</key><value>math.sqrt(math.pow(10.0,ttlevel/10))</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>ttlevel</value></param>
<param><key>label</key><value>Test Tone Level</value></param>
<param><key>value</key><value>tlevel</value></param>
<param><key>min</key><value>-60</value></param>
<param><key>max</key><value>0</value></param>
<param><key>num_steps</key><value>50</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1,0,1,1</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>rgain</value></param>
<param><key>label</key><value>RX RF Gain</value></param>
<param><key>value</key><value>rxgain</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>50.0</value></param>
<param><key>num_steps</key><value>50</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0,4,1,1</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>gr_probe_signal_f</key>
<param><key>id</key><value>rxprobe</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_foo_0</value></param>
<param><key>note</key><value>Power Level probe</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frequency</value></param>
<param><key>value</key><value>225.0e6</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>f</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>RXPWRLOG</value></param>
<param><key>value</key><value>preemph.rxpower_log(rxprobeout)</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>probeout</value></param>
<param><key>value</key><value>0</value></param>
<param><key>block_id</key><value>myprobe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>clipval</value></param>
<param><key>value</key><value>"**YES**" if probeout &gt; CLIPLIM else "NO"</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>rxprobeout</value></param>
<param><key>value</key><value>0.0</value></param>
<param><key>block_id</key><value>rxprobe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rxlvl</value></param>
<param><key>value</key><value>0 if rxprobeout &lt;= 0.0 else math.log10(rxprobeout)*10.0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>offset</value></param>
<param><key>label</key><value>Test tone offset</value></param>
<param><key>value</key><value>toffset</value></param>
<param><key>min</key><value>10e3</value></param>
<param><key>max</key><value>(srate/2)-1e3</value></param>
<param><key>num_steps</key><value>40</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1,2,1,1</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>test_tones</value></param>
<param><key>label</key><value>Test Tones On</value></param>
<param><key>value</key><value>xton</value></param>
<param><key>true</key><value>1.0</value></param>
<param><key>false</key><value>0.0</value></param>
<param><key>grid_pos</key><value>1,1,1,1</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>gr_add_xx</key>
<param><key>id</key><value>gr_add_xx_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_probe_avg_mag_sqrd_x</key>
<param><key>id</key><value>myprobe</value></param>
<param><key>type</key><value>c</value></param>
<param><key>threshold</key><value>-20</value></param>
<param><key>alpha</key><value>1</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>txmute</value></param>
<param><key>label</key><value>TX Mute</value></param>
<param><key>value</key><value>False</value></param>
<param><key>true</key><value>1.0</value></param>
<param><key>false</key><value>0.0</value></param>
<param><key>grid_pos</key><value>1,3,1,1</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>scale</value></param>
<param><key>label</key><value>scaling of input values</value></param>
<param><key>value</key><value>math.pow(2.0,15)</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rxant</value></param>
<param><key>label</key><value>receive antenna port</value></param>
<param><key>value</key><value>RX2</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frate</value></param>
<param><key>label</key><value>FFT Frame Rate</value></param>
<param><key>value</key><value>5</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_0_0_0</value></param>
<param><key>label</key><value>CLIPPED</value></param>
<param><key>value</key><value>clipval</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>3,5,1,1</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_0_0_1</value></param>
<param><key>label</key><value>Rel RX Level (dB)</value></param>
<param><key>value</key><value>rxlvl</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>preemph.dbf</value></param>
<param><key>grid_pos</key><value>3,3,1,1</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_0_0</value></param>
<param><key>label</key><value>Channel Freq</value></param>
<param><key>value</key><value>frequency+tweak</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>preemph.freqf</value></param>
<param><key>grid_pos</key><value>3,2,1,1</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>srl</value></param>
<param><key>label</key><value>Note</value></param>
<param><key>value</key><value>"This Flowgraph brought to you by Science Radio Laboratories: http://www.science-radio-labs.com"</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>2,0,1,5</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>TX Baseband Monitor</value></param>
<param><key>samp_rate</key><value>srate</value></param>
<param><key>baseband_freq</key><value>frequency</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>50</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>frate</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.375</value></param>
<param><key>win</key><value>None</value></param>
<param><key>win_size</key><value>650,400</value></param>
<param><key>notebook</key><value>Main,1</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>RX Monitor</value></param>
<param><key>samp_rate</key><value>srate</value></param>
<param><key>baseband_freq</key><value>frequency</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>50</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>frate</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.375</value></param>
<param><key>win</key><value>None</value></param>
<param><key>win_size</key><value>650,400</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rfgain</value></param>
<param><key>label</key><value>tx-side analog gain</value></param>
<param><key>value</key><value>25.0</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>g</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>dev_addr</key><value>devid</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>sd_spec0</key><value>dbspec</value></param>
<param><key>samp_rate</key><value>srate</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(frequency+tweak,srate/1.9)</value></param>
<param><key>gain0</key><value>vgain</value></param>
<param><key>ant0</key><value>txant</value></param>
</block>
<block>
<key>gr_complex_to_mag_squared</key>
<param><key>id</key><value>gr_complex_to_mag_squared_0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_foo</value></param>
<param><key>note</key><value>On-air monitor</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_0</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>value</key><value>srate</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>3,0,1,1</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>a1label</value></param>
<param><key>label</key><value>First analysis label</value></param>
<param><key>value</key><value>Unused</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>a2label</value></param>
<param><key>label</key><value>Second analysis label</value></param>
<param><key>value</key><value>Unused</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>a3label</value></param>
<param><key>label</key><value>Third analysis label</value></param>
<param><key>value</key><value>Unused</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>a4label</value></param>
<param><key>label</key><value>Fourth analysis label</value></param>
<param><key>value</key><value>Unused</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dgain</value></param>
<param><key>label</key><value>digital gain adjustment (dB)</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>dgslider</value></param>
<param><key>label</key><value>Digital Gain</value></param>
<param><key>value</key><value>dgain</value></param>
<param><key>min</key><value>-30</value></param>
<param><key>max</key><value>30</value></param>
<param><key>num_steps</key><value>50</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0,5,1,1</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>toffset</value></param>
<param><key>label</key><value>test-tone offset</value></param>
<param><key>value</key><value>100e3</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>afile</value></param>
<param><key>label</key><value>Analysis output filename</value></param>
<param><key>value</key><value>/dev/null</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>Main</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
<param><key>labels</key><value>['Controls+RX Mon', 'TX Mon','RX Power history',atitle]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>atitle</value></param>
<param><key>label</key><value>Title of Analysis Tab</value></param>
<param><key>value</key><value>Analysis plugin data</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>a2_text</value></param>
<param><key>label</key><value>a2label</value></param>
<param><key>value</key><value>a2_value</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>4,1,1,1</value></param>
<param><key>notebook</key><value>Main,3</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>a3_text</value></param>
<param><key>label</key><value>a3label</value></param>
<param><key>value</key><value>a3_value</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>6,1,1,1</value></param>
<param><key>notebook</key><value>Main,3</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>a4_text</value></param>
<param><key>label</key><value>a4label</value></param>
<param><key>value</key><value>a4_value</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>8,1,1,1</value></param>
<param><key>notebook</key><value>Main,3</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>a1_text</value></param>
<param><key>label</key><value>a1label</value></param>
<param><key>value</key><value>a1_value</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>2,1,1,1</value></param>
<param><key>notebook</key><value>Main,3</value></param>
</block>
<block>
<key>xmlrpc_server</key>
<param><key>id</key><value>xmlrpc_server_0</value></param>
<param><key>addr</key><value>localhost</value></param>
<param><key>port</key><value>port</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gval</value></param>
<param><key>value</key><value>math.sqrt(math.pow(10.0,dgslider/10))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>prex</value></param>
<param><key>value</key><value>False if pemph == 0 else True</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vgain</value></param>
<param><key>value</key><value>gain if txmute &lt;= 0.0 else 0.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>xton</value></param>
<param><key>value</key><value>False if ton == 0 else True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>port</value></param>
<param><key>label</key><value>XMLRPC Port</value></param>
<param><key>value</key><value>8081</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>0 if txmute &gt; 0 else 1.0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>RX Power History</value></param>
<param><key>samp_rate</key><value>4</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>225</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>notebook</key><value>Main,2</value></param>
<param><key>trig_mode</key><value>gr.gr_TRIG_MODE_STRIPCHART</value></param>
<param><key>y_axis_label</key><value>Relative RX Power (dB)</value></param>
</block>
<block>
<key>gr_nlog10_ff</key>
<param><key>id</key><value>gr_nlog10_ff_0</value></param>
<param><key>n</key><value>10</value></param>
<param><key>k</key><value>0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_keep_one_in_n</key>
<param><key>id</key><value>gr_keep_one_in_n_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>n</key><value>srate/4</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_single_pole_iir_filter_xx</key>
<param><key>id</key><value>gr_single_pole_iir_filter_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>alpha</key><value>1.0/(srate/2.5)</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>dev_addr</key><value>devid</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>sd_spec0</key><value>dbspec</value></param>
<param><key>samp_rate</key><value>srate</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(frequency,srate/1.9)</value></param>
<param><key>gain0</key><value>rgain</value></param>
<param><key>ant0</key><value>rxant</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>gr_file_sink_0</value></param>
<param><key>file</key><value>afile</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>a1_text_0</value></param>
<param><key>label</key><value>Note</value></param>
<param><key>value</key><value>atitle</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>notebook</key><value>Main,3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>a1_value</value></param>
<param><key>value</key><value>"--"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>a2_value</value></param>
<param><key>value</key><value>"--"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>a3_value</value></param>
<param><key>value</key><value>"--"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>a4_value</value></param>
<param><key>value</key><value>"--"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rxgain</value></param>
<param><key>label</key><value>rx-side analog gain</value></param>
<param><key>value</key><value>15.0</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>final_freq</value></param>
<param><key>value</key><value>frequency+tweak</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>srate</value></param>
<param><key>label</key><value>hw sample rate</value></param>
<param><key>value</key><value>int(3.2e6)</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>short_id</key><value>r</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>UHD expects {-1.0,+1.0}</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>(1.0/scale)*gval</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>psiz</value></param>
<param><key>label</key><value>Preemphasis filter size</value></param>
<param><key>value</key><value>128</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>fsize</value></param>
<param><key>label</key><value>Preemph Filter Length</value></param>
<param><key>value</key><value>psiz</value></param>
<param><key>choices</key><value>[128, 256, 512]</value></param>
<param><key>labels</key><value>[]</value></param>
<param><key>type</key><value>radio_buttons</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>grid_pos</key><value>0,2,1,1</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>gr_fft_filter_xxx</key>
<param><key>id</key><value>gr_fft_filter_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>preemph.compute_preemph(pre_on,int(fsize))</value></param>
</block>
<connection><source_block_id>gr_file_source_0</source_block_id><sink_block_id>gr_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_sig_source_x_0</source_block_id><sink_block_id>gr_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_sig_source_x_0_0</source_block_id><sink_block_id>gr_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_add_xx_0</source_block_id><sink_block_id>gr_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_1</source_block_id><sink_block_id>gr_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_fft_filter_xxx_0</source_block_id><sink_block_id>gr_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>gr_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_mag_squared_0</source_block_id><sink_block_id>gr_single_pole_iir_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_single_pole_iir_filter_xx_0</source_block_id><sink_block_id>gr_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_keep_one_in_n_0</source_block_id><sink_block_id>rxprobe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_nlog10_ff_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_keep_one_in_n_0</source_block_id><sink_block_id>gr_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_add_xx_1</source_block_id><sink_block_id>gr_multiply_const_vxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_2</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_2</source_block_id><sink_block_id>wxgui_fftsink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_2</source_block_id><sink_block_id>myprobe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>gr_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0</source_block_id><sink_block_id>gr_fft_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
